# Keil uVision project stm32f103_rtt_2021.03.13.uvprojx, settings and files
target stm32_rtt_atk (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103_rtt_2021.03.13
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\src\rt_thread\bsp;..\src\rt_thread\include;..\src\rt_thread\include\libc;..\src\rt_thread\components\finsh;..\src\stm32f103_libraries\CMSIS\CM3\CoreSupport;..\src\stm32f103_libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\src\stm32f103_libraries\STM32F10x_StdPeriph_Driver\inc;..\src\user\inc;..\src\divers\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group cmsis
    ../src/stm32f103_libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../src/stm32f103_libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h stm32f10x_conf.h system_stm32f10x.c system_stm32f10x.h
    ../src/stm32f103_libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group stm32_lib
    ../src/stm32f103_libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group rtt/src
    ../src/rt_thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group rtt/cm3
    ../src/rt_thread/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
  group rtt/components
    ../src/rt_thread/components/finsh/: cmd.c msh.c shell.c
  group rtt/bsp
    ../src/rt_thread/bsp/: board.c rtconfig.h
  group user
    ../src/user/: main.c user_cmd.c
  group divers
    ../src/divers/: lcd.c led.c usart.c
